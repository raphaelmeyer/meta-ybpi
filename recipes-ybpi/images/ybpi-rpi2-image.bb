SUMMARY = "A small image just capable of allowing a device to boot."

inherit rpi-hwup-image

