SUMMARY = "YoBerryPi image"

LICENSE = "MIT"

include recipes-core/images/rpi-hwup-image.bb

