
IMAGE_INSTALL += " \
  load-i2c-module \
  libstdc++ \
  userland \
  "

